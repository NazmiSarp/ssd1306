# Keil uVision project 02.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: -AT32F413CBT7 ArteryTek
  pack: ArteryTek.AT32F413_DFP.2.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 02
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c i2c_application.c i2c_config.c ssd1306.c ssd1306_fonts.c
  group inc
    ./: i2c_application.h i2c_config.h ssd1306.h ssd1306_fonts.h ssd1306_conf_template.h
software components: CMSIS:CORE 6.1.0, Device:Startup 2.0.0, Device:at32f413_conf 2.0.0, Device:at32f413_firmware_library:crm 2.0.0, Device:at32f413_firmware_library:dma 2.0.0, Device:at32f413_firmware_library:gpio 2.0.0, Device:at32f413_firmware_library:i2c 2.0.0, Device:at32f413_firmware_library:misc 2.0.0, Compiler:Event Recorder 1.5.1
